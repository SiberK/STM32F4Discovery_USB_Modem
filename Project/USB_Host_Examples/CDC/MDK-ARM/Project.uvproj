# Keil uVision project Project.uvproj, settings and files
target Discover-More_USBH-HS (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=2 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Utilities\STM32F4-Discovery;..\..\..\..\Utilities\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../src/: stm32fxxx_it.c usb_bsp.c main.c usbh_usr_lcd.c
  group USB Host
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../../Libraries/STM32_USB_HOST_Library/Class/CDC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group FAT FS
    ../../../../Utilities/fat_fs/src/: fattime.c ff.c
  group STM32F4xx
    ../src/: system_stm32f4xx.c
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_dma.c
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c lcd_log.c
  group Readme
    ../: readme.txt
target Discover-More_USBH-FS (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS,USE_ULPI_PHY
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\CDC\inc;..\..\..\..\Utilities\STM32F4-Discovery;..\..\..\..\Utilities\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
